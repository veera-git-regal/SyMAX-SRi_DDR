# IAR project 4.5kW_GMI_DecStar.ewp, settings and files
configuration 1.3kW_GMI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F301C8 ST STM32F301C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include; ..\FlexMouse\Drivers; ..\FlexMouse\Features; ..\FlexMouse\Kernel; ..\FlexMouse\Memory; ..\FlexMouse\Regal; ..\FlexMouse\UniversalProtocol; ..\FlexMouse\Motor
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.3kW_GMI.hex
  postbuild: "$EXE_DIR$\generate_crc.bat" "$TOOLKIT_DIR$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: 1.3kW_GMI.out
  ILINK.IlinkIcfFile: stm32f302x8_flash_with_meerkat.icf
  ILINK.IlinkAdditionalLibs: C:\Project_data\ECM_data\ADC_calibration\symax_sri_drive-baeabf5a083b9d6807dd5098fc07bf164ff567a2\EWARM\meerkat_safety.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: vEE_climate.txt
  group Application/EWARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: dac_ui.c harmonic_injection.c main.c mc_api.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c stm32f30x_mc_it.c stm32f3xx_hal_msp.c stm32f3xx_it.c ui_task.c user_interface.c
  group Application/User/ST_Regal
    ../Src/ST_Regal/: mc_config.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_adc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_i2c.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group FlexMouse/Drivers
    ../FlexMouse/Drivers/: driver_i2c.c driver_rtc.c driver_usart1.c driver_usart1.h module_err_logHande.c module_err_logHandle.h module_flash.c module_i2c.c module_rtc.c module_usart1.c module_usart1.h zz_module_flash.h
  group FlexMouse/Features
    ../FlexMouse/Features/: module_app.c module_app.h module_ecm_icl.c module_ecm_icl.h module_meerkat_interface.c module_meerkat_shared_rom.c module_voltage_doubler.c module_voltage_doubler.h
  group FlexMouse/Kernel
    ../FlexMouse/Kernel/: scheduler.c scheduler.h sequential_memory.c sequential_memory.h structured_memory.c structured_memory.h
  group FlexMouse/Memory
    ../FlexMouse/Memory/: ram_buffer.c ram_buffer.h ring_buffer.c ring_buffer.h
  group FlexMouse/Motor
    ../FlexMouse/Motor/: ab_module_Mc_StateMachine.h module_Mc_StateMachine.c regal_mc_lib.c regal_mc_lib.h
  group FlexMouse/Regal
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c
    ../FlexMouse/Regal/: typedef.h
  group FlexMouse/UniversalProtocol
    ../FlexMouse/UniversalProtocol/: module_AutoAck.c module_AutoAck.h module_EEPCmd.c module_FlashRegisterCmd.c module_FlashRegisterCmd.h module_FlashUpdateCmd.c module_FlashUpdateCmd.h module_ReplyCmd.c module_ReplyCmd.h module_ShortCmd.c module_ShortCmd.h
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c hall_speed_pos_fdbk.c inrush_current_limiter.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c ui_irq_handler.c usart_frame_communication_protocol.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_1_f30x_pwm_curr_fdbk.c
